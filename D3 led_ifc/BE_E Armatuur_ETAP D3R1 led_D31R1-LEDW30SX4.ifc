Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2016-06-15T11:30:20
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160525_1230(x64) - Exporter 16.0.1144.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jun 15 11:30:20 2016 * Host: gebruiker-PC * Database: C:\Users\GEBRUI~1\AppData\Local\Temp\{E058C0B7-F437-4543-B851-C3F14D6CF2E3}\ifc * Database version: 5507 * Database creation date: Wed Jun 15 11:30:20 2016 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jun 15 11:30:20 2016 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jun 15 11:30:20 2016 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Identity Data - Type Name: 8mm Head; Building Story: yes; Name: Level 1; Structural: no
Graphics - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm

# IfcFlowTerminal: D31R1-LEDW30SX4, Dummy:D31R1-LEDW30SX4:209074
In: Level 1
Type - Material: BE Armatuur, BE Kader, BE_G Glas lamp
Type - Constraints - Default Elevation: 1000 mm; WT_H Behuizing: Standaard; WT_H Breedte: 192 mm; WT_H Coarse geometrie: Standaard; WT_H Halve breedte negatief: -96 mm; WT_H Halve lengte negatief: -96 mm; WT_H Hoogte: 125 mm; WT_H Inbouw: yes; WT_H Inbouwdiepte: 124 mm; WT_H Lengte: 192 mm; WT_H Offset lichtbron: 0 mm; WT_H Optie_geen: Geen; WT_H Optie_IP44 uitvoering: IP44; WT_H Referentie: Inbouw; WT_H Symbool wand hoogte: 125 mm; WT_H Symbool wand lengte: 192 mm; WT_H Uitsnijding_breedte: 175 mm; WT_H Uitsnijding_lengte: 175 mm; WT_H Uitsteek: 0 mm
Type - Construction - WT_V IP44 uitvoering: no
Type - Dimensions - BE_G Breedte: 192 mm; BE_G Hoogte: 125 mm; BE_G Lengte: 192 mm
Type - Electrical - BE_E Arbeidsfactor: 1; BE_E Belastingsklasse: Verlichting; BE_E Schijnbaar vermogen: 29.2 W; BE_E Spanning: 230 V
Type - Electrical - Loads - Apparent Load: 29.2 W
Type - Graphics - WT_V Symbool plafond: led-rechthoekige; WT_V Symbool wand: geen
Type - Identity Data - BE_I Bestelcode: D31R1/LEDW30SX4; Manufacturer: ETAP; Model: D3R1 led; Type Name: D31R1-LEDW30SX4; WT_I BaseKeynote: 63.1
Type - Materials and Finishes - WT_V Materiaal armatuur: BE Armatuur; WT_V Materiaal kader: BE Kader
Type - Model Properties - WT_I Armatuurrendement: 0.9; WT_I Dimbaar: Nee; WT_I IP klasse: -; WT_I Kleur: RAL9006; WT_I Maatschets catalogus: -; WT_I Maximale temperatuur: -; WT_I Montage: Inbouw; WT_I Optiek: downlight - breedstralend; WT_I UGR: <=22; WT_I Uitsnijding: 175 x 175; WT_I Voorschakelapparaat: S; WT_I Vorm: downlight
Type - Other - Category: Lighting Fixtures; Family Name: Dummy; WT_c1 Omschrijving: c1_Elektrische voeding
Type - Photometrics - WT_H Lichtbron: BE_E_GEO Armatuur_ETAP D3 - lichtbron - LED: D31R1_LEDW30X3_S; WT_I Aantal lampen: 1; WT_I Afschermhoek: 0 deg; WT_I Lamptype: LED; WT_I Luminantie: 0; WT_I Vermogen lamp: 29.2 W
Pset_ManufacturerTypeInformation - Manufacturer: ETAP
Pset_DistributionFlowElementCommon - Reference: D31R1-LEDW30SX4
Constraints - Elevation: 0 mm; Host: Level : Level 1; Level: Level: Level 1; WT_H Optie: Geen
Dimensions - Area: 0.37827 m2; Volume: 0.0168876 m3
Electrical - Circuiting - Electrical Data: c1_Elektrische voeding 230 V/1-29 VA
Electrical - Lighting - Calculate Coefficient of Utilization: no
Identity Data - Mark: 3
Other - Family: Dummy: D31R1-LEDW30SX4; Family and Type: Dummy: D31R1-LEDW30SX4; Schedule Level: Level: Level 1; Type: Dummy: D31R1-LEDW30SX4; Type Id: Dummy: D31R1-LEDW30SX4
Phasing - Phase Created: 469492
